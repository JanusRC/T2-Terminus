# Keil uVision project Project.uvproj, settings and files
target TERMINUS2 (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: T2_VCP_Demo +hex
  AfterMake: ..\T2APPACK TERMINUS2\T2_VCP_Demo.HEX
  AfterMake: AppPackRename.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_JANUS_T2, STM32F2XX, USE_STDPERIPH_DRIVER, USE_USB_OTG_FS, HSE_VALUE=16000000
  c include: ..\;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../: main.c stm32fxxx_it.c
  group STM32F2xx_StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group CMSIS
    ../: system_stm32f2xx.c
  group MDK-ARM
    ../: startup_stm32f2xx.s
  group USB
    ../: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c usbd_cdc_vcp.c usbd_cdc_core.c
  group BOARD
    ../: janus_t2.c
