# Keil uVision project Project.uvproj, settings and files
target TERMINUS2 (ARM-ADS)
  device: STM32F405ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: TERMINUS2 +hex
  AfterMake: ..\T2APPACK TERMINUS2\TERMINUS2.HEX
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_JANUS_T2, STM32F40_41xxx, USE_STDPERIPH_DRIVER, USE_USB_OTG_FS, HSE_VALUE=16000000
  c include: ..\;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../: main.c stm32fxxx_it.c
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../: startup_stm32f40xx.s
  group USB
    ../: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c usbd_cdc_vcp.c usbd_cdc_core.c
  group BOARD
    ../: janus_t2.c
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
